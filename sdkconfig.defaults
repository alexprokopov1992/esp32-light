## sdkconfig.defaults
```kconfig
CONFIG_IDF_COMPONENT_MANAGER_ENABLED=y
CONFIG_HTTPD_MAX_REQ_HDR_LEN=4096
CONFIG_HTTPD_MAX_URI_LEN=1024
```
